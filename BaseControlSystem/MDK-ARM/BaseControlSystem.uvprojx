# Keil uVision project BaseControlSystem.uvprojx, settings and files
target BaseControlSystem (5060960::V5.06 update 7 (build 960)::.\ARMCOMPLIER506)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: BaseControlSystem +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F411xE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../BSP/inc;../APP/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group APP_src
    ../APP/Src/: chassis_task.c kinematics.c pid.c app_init.c app_navigate.c navi_task.c coord_solver.c map_manager.c path_planner.c
  group BSP_src
    ../BSP/Src/: bsp_callbacks.c bsp_encoder.c bsp_lidar.c bsp_motor.c bsp_uart.c bsp_uwb.c mpu6050.c
  group BSP_Inc
    ../BSP/Inc/: bsp_callbacks.h bsp_encoder.h debug_config.h bsp_lidar.h bsp_motor.h bsp_uart.h bsp_uwb.h mpu6050.h
  group APP_Inc
    ../APP/Inc/: chassis_task.h Header.h kinematics.h pid.h app_init.h app_navigate.h navi_task.h coord_solver.h map_manager.h path_planner.h
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Application/MDK-ARM
    ./: startup_stm32f411xe.s
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group READEME
    ../: README.txt TechDoc.txt
software components: CMSIS:CORE 4.3.0
